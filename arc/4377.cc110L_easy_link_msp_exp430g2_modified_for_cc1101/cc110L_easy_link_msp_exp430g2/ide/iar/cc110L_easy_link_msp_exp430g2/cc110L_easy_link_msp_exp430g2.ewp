# IAR project cc110L_easy_link_msp_exp430g2.ewp, settings and files
configuration TX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP_EXP430G2
  ICC430.newCCIncludePaths: ..\..\..\source\components\targets\msp_exp430g2; ..\..\..\source\components\targets\interface; ..\..\..\source\components\common; ..\..\..\source\components\devices\cc11xL; ..\..\..\source\components\devices\cc1101
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration RX (MSP430, debug)
  as the first configuration, except:
  group (top)
    ../../../source/apps/cc110L_easy_link_msp_exp430g2/: cc110L_easy_link_msp_exp_430g2_rx.c cc110L_easy_link_msp_exp_430g2_tx.c cc11xL_easy_link_msp_exp_430g2_reg_config.h
  group hal
    ../../../source/components/devices/cc1101/: cc1101_spi.c
    ../../../source/components/targets/msp_exp430g2/: hal_board.c hal_digio2.c hal_int_rf_msp_exp430g2.c hal_msp_exp430g2_spi.c
