<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc110L_easy_link_msp_exp430g2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


